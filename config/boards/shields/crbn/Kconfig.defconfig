## config/boards/shields/crbn/Kconfig.shield
```kconfig
# Copyright 2020 The ZMK Contributors
# SPDX-Liscense-Idenfifier: MIT

config SHIELD_CRBN
	def_bool $(shields_list_contains,crbn)
```
